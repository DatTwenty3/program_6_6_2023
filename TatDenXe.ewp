# IAR project TatDenXe.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: D:\A16\2022\Thang7\TatDenXe\STM8S_StdPeriph_Driver\inc; D:\A16\2022\Thang7\TatDenXe; D:\Work\Projects STM8\program_6_6_2023
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TEST 2 FET.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: define.h main.c
